# Keil uVision project CH579F-xdtq.uvprojx, settings and files
target CH57F-xdtq (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH57x +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\..\os\ble\HAL\include;..\..\os\core\CMSIS\Include;..\..\os\core\StdPeriphDriver\inc;..\..\os\common;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  group app
    ./: kxtj9.c kxtj9.h Main.c
  group os-common
    ../../os/common/: gpio_to_i2c.c gpio_to_i2c.h
  group os-startup
    ../../os/core/Startup/: startup_ARMCM0.s
  group os-core
    ../../os/core/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c CH57x_usbhostBase.c CH57x_usbhostClass.c
  group os-core-inc
    ../../os/core/StdPeriphDriver/inc/: CH57x_adc.h CH57x_clk.h CH57x_common.h CH57x_flash.h CH57x_gpio.h CH57x_lcd.h CH57x_pwm.h CH57x_pwr.h CH57x_spi.h CH57x_sys.h CH57x_timer.h CH57x_uart.h CH57x_usbdev.h CH57x_usbhost.h CH579SFR.h
